# Keil uVision project myProject.uvprojx, settings and files
target default (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: OSAPI_USE_FREERTOS
  c include: .\cunit\Headers;.\osapi;.\osapi_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ./application/: main.cpp
  group cunit
    ./cunit/Sources/Basic/: Basic.c
    ./cunit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
  group osapi
    ./: osapi_mutex_freertos.h RecursiveMutex.h
    ./osapi/: osapi_mutex_interface.h osapi_thread_interface.h osapi.h osapi_mortal_thread.h
    ./osapi/freertos/: osapi_thread_freertos.h osapi_freertos.cpp
  group osapi_test
    ./osapi_test/: test_00_thread_name.cpp test_01_thread_creation.cpp test_02_thread_join.cpp test_03_thread_suspend_resume.cpp test_04_thread_priority.cpp test_05_thread_delay.cpp test_06_mutex.cpp test_07_recursive_mutex.cpp test_08_mortal_thread.cpp test_osapi.cpp test_osapi.h test_14_thread_stack_size.cpp test_13_thread_suspend_inactive.cpp test_12_thread_state.cpp test_11_thread_run_detailed.cpp test_10_thread_priority_change.cpp
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:Startup 2.6.3
